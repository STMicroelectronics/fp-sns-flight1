# IAR project FLIGHT1.ewp, settings and files
configuration FLIGHT1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/parson; ../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/53L3A2; ../../../../../../Drivers/BSP/Components/vl53l3cx/modules; ../../../../../../Drivers/BSP/Components/vl53l3cx/porting; ../../../../../../Drivers/BSP/Components/vl53l3cx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FLIGHT1.bin
  ILINK.IlinkOutputFile: FLIGHT1.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c ota.c target_platform.c ble_function.c app_flight1.c hci_tl_interface.c ble_implementation.c stm32u5xx_nucleo_bus.c stm32u5xx_nucleo.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/53L3A2
    ../../../../../../Drivers/BSP/53L3A2/: 53l3a2.c 53l3a2_ranging_sensor.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l3cx/modules/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_register_funcs.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c
    ../../../../../../Drivers/BSP/Components/vl53l3cx/porting/: vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c
    ../../../../../../Drivers/BSP/Components/vl53l3cx/: vl53l3cx.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/ObjectsDetection
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_objects_detection.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../../Drivers/BSP/53L3A2/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l3cx/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l3cx/modules/: LXReleaseNotes.txt
