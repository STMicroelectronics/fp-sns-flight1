# IAR project Project.ewp, settings and files
configuration STM32F401RE-Nucleo_FLIGHT1 (ARM)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; STM32_NUCLEO; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa50
  ICCARM.IExtraOptions: --aeabi; --guard_calls
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes; ..\..\..\..\..\Middlewares\ST\lib_nfc\lib_NDEF\Core\inc; ..\..\..\..\..\Middlewares\ST\lib_nfc\Common\inc; ..\..\..\..\..\Drivers\BSP\NFC04A1; ..\..\..\..\..\Drivers\BSP\Components\ST25DV; ..\..\..\..\..\Drivers\BSP\53L3A2; ..\..\..\..\..\Drivers\BSP\Components\vl53l3cx; ..\..\..\..\..\Drivers\BSP\Components\vl53l3cx\modules; ..\..\..\..\..\Drivers\BSP\Components\vl53l3cx\porting; ..\..\..\..\..\Middlewares\ST\STM32_BLE_Manager\Inc; ..\..\..\..\..\Middlewares\Third_Party\parson
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo_FLIGHT1.bin
  ILINK.IlinkOutputFile: STM32F401RE-Nucleo_FLIGHT1.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/ST25DV
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/BSP/Components/vl53L3cx
    ../../../../../Drivers/BSP/Components/vl53l3cx/: vl53l3cx.c
  group Drivers/BSP/Components/vl53L3cx/Modules
    ../../../../../Drivers/BSP/Components/vl53l3cx/modules/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_register_funcs.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c
  group Drivers/BSP/Components/vl53L3cx/Porting
    ../../../../../Drivers/BSP/Components/vl53l3cx/porting/: vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c
  group Drivers/BSP/X-NUCLEO-53L3A2
    ../../../../../Drivers/BSP/53L3A2/: 53l3a2.c 53l3a2_ranging_sensor.c
  group Drivers/BSP/X-NUCLEO-NFC04A1
    ../../../../../Drivers/BSP/NFC04A1/: nfc04a1.c nfc04a1_nfctag.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Led.c BLE_Manager.c BLE_ObjectsDetection.c
  group Middlewares/BlueNRG-MS/HCI
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/HCI/controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/HCI/hci_tl_patterns/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/json
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/Lib_NDEF
    ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_URI.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Nucleo-F401RE_FLIGHT1/EWARM
    ./: startup_stm32f401xe.s
  group Nucleo-F401RE_FLIGHT1/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c lib_NDEF_config.c main.c OTA.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_nucleo.c stm32f4xx_nucleo_bus.c TargetPlatform.c
